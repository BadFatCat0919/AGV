# Keil uVision project AGV.uvprojx, settings and files
target AGV (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AGV +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\OLED;..\HARDWARE\KEY;..\SOLGUI;..\SOLGUI\Font;..\HARDWARE\LED;..\HARDWARE\DMP;..\HARDWARE\EXTI;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\SYSTEM\usart;..\CONTROL;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\HARDWARE\ENCODER;..\HARDWARE\BUZZER;..\HARDWARE\USART;..\HARDWARE\CCD;..\HARDWARE\ADC;..\HARDWARE\WIRELESS;..\HARDWARE\OpenMV
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c menu.c system_stm32f10x.c
  group CONTROL
    ../CONTROL/: match.c action.c control.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/BUZZER/: buzzer.c
    ../HARDWARE/USART/: UNO.c
    ../HARDWARE/CCD/: ccd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/WIRELESS/: wireless.c
    ../HARDWARE/OpenMV/: OpenMV.c
  group SOLGUI
    ../SOLGUI/: SOLGUI_Common.c SOLGUI_GBasic.c SOLGUI_Hardware.c SOLGUI_Menu.c SOLGUI_Picture.c SOLGUI_Printf.c SOLGUI_Widget.c
    ../SOLGUI/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_adc.c
